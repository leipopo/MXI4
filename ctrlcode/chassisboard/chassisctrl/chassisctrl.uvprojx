# Keil uVision project chassisctrl.uvprojx, settings and files
target chassisctrl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: chassisctrl
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: Inc;Drivers\STM32F4xx_HAL_Driver\Inc;Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;Middlewares\Third_Party\FreeRTOS\Source\include;Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\CMSIS\Include;.cmsis\dsp_lib;.cmsis\include;.eide\deps;Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F
  asm define: USE_HAL_DRIVER,STM32F427xx
  memory RVCT1: RAM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x5000
  group Middlewares/FreeRTOS
    ../../gimbalboard/gimbctrl/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers
    ./: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal.c
  group Drivers/CMSIS
    Src/: system_stm32f4xx.c
  group Application/User
    Src/: can.c dma.c freertos.c gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Application/User/tasks
    Src/tasks/: capsctrl.c chasctrl.c comutask.c devmoni.c gimbctrl.c infoupdate.c init.c reftask.c UIdrawer.c
  group Application/User/libs
    Src/libs/: crc8_crc16.c fifo.c motlib.c pid.c ref.c
  group Application/User/devices
    Src/devices/: canbus.c rc.c
  group Application/User/bsps
    Src/bsps/: can_bsp.c dma_bsp.c flash_bsp.c
